# Keil uVision project uCOS-III.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: uCOS_app1
  AfterMake: fromelf --bin ".\Output\@L.axf" --output ".\Output\@L.bin"
  AfterMake: fromelf --text -c ".\Output\@L.axf" --output ".\Output\@L.txt"
  c flags: Optim=4 OneElfS=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\uCOS-III\uCOS-III\Source;..\..\..\..\ThirdParty\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\ThirdParty\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\ThirdParty\uCOS-III\uC-CPU;..\..\..\..\ThirdParty\uCOS-III\uC-LIB;..\..\..\..\ThirdParty\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4;..\..\BSP;..\;.\
  asm define: __TARGET_FPU_VFP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../: app.c os_app_hooks.c
  group BSP
    ../../BSP/: bsp.c bsp_int.c bsp_os.c
    ../../BSP/KeilMDK/: cstartup.s
  group uC/CPU
    ../../../../ThirdParty/uCOS-III/uC-CPU/: cpu_core.c
    ../../../../ThirdParty/uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../ThirdParty/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../ThirdParty/uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../../../ThirdParty/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../../../ThirdParty/uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group Drivers
    ../../../../Library/StdDriver/src/: crypto.c sys.c
