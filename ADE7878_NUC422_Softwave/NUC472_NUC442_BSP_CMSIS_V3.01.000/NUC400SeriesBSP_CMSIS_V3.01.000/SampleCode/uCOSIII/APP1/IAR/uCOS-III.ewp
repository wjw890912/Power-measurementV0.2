# IAR project uCOS-III.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; ..\..\..\..\Library\StdDriver\inc; ; ..; ..\..\..\..\SampleCode\uCOSIII\BSP; ..\..\..\..\ThirdParty\uCOS-III\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\ThirdParty\uCOS-III\uC-CPU; ..\..\..\..\ThirdParty\uCOS-III\uC-LIB; ..\..\..\..\ThirdParty\uCOS-III\uCOS-III\Source; ..\..\..\..\ThirdParty\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS-III.bin
  ILINK.IlinkOutputFile: uCOS-III.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group APP
    ../: app.c os_app_hooks.c
  group BSP
    ../../BSP/: bsp.c bsp_int.c bsp_os.c
    ../../BSP/IAR/: cstartup.c
  group Drivers
    ../../../../Library/StdDriver/src/: crypto.c sys.c
  group uC/CPU
    ../../../../ThirdParty/uCOS-III/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../../../../ThirdParty/uCOS-III/uC-CPU/: cpu_core.c
  group uC/LIB
    ../../../../ThirdParty/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III Port
    ../../../../ThirdParty/uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-III Source
    ../../../../ThirdParty/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
