# Keil uVision project FreeRTOS_lwip_httpd.uvproj, settings and files
target FreeRTOS_lwip_httpd (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTOSDemo +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\Library\StdDriver\inc;..\..\..\ThirdParty\FreeRTOS\DEMO\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\;..\..\..\ThirdParty\lwip-1.4.1\src\include;..\..\..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\port\FreeRTOS\include;..\lwip-1.4.1\port\FreeRTOS\include\arch;..\lwip-1.4.1\port\FreeRTOS\include\lwip;..\lwip-1.4.1\port\FreeRTOS\include\netif;..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000000
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: main.c fs.c httpserver-netconn.c
  group FreeRTOS
    ../../../ThirdParty/FreeRTOS/SOURCE/: list.c tasks.c timers.c queue.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/RVDS/ARM_CM4F/: port.c
    ../../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: GenQTest.c semtest.c QueueSet.c PollQ.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group lwIP
    ../lwip-1.4.1/port/FreeRTOS/: sys_arch.c time_stamp.c
    ../lwip-1.4.1/port/FreeRTOS/netif/: ethernetif.c nuc472_eth.c
    ../../../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timers_lwip.c udp.c
    ../../../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
