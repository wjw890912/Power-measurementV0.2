# IAR project FreeRTOS_lwip_httpd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __TARGET_FPU_VFP
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\NUC472_442\Include; ..\..\..\Library\StdDriver\inc; ..\..\..\ThirdParty\FreeRTOS\SOURCE\include; ..\..\..\ThirdParty\FreeRTOS\DEMO\COMMON\include; ..; ..\..\..\ThirdParty\FreeRTOS\Common\include; ..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F; ..\lwip-1.4.1\port\FreeRTOS\include; ..\lwip-1.4.1\port\FreeRTOS\include\arch; ..\lwip-1.4.1\port\FreeRTOS\include\lwip; ..\lwip-1.4.1\port\FreeRTOS\include\netif; ..\..\..\ThirdParty\lwip-1.4.1\src\include\; ..\..\..\ThirdParty\lwip-1.4.1\src\include\ipv4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: RVDS_ARMCM4_NUC4xx; __TARGET_FPU_VFP
  AARM.AUserIncludes: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\; $PROJ_DIR$..\..\..\Common\include
  OBJCOPY.OOCOutputFile: FreeRTOS_lwip_httpd.bin
  ILINK.IlinkOutputFile: FreeRTOS_lwip_httpd.out
  ILINK.IlinkIcfFile: FreeRTOS_lwip_httpd.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group FreeRTOS
    ../../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/SOURCE/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group lwIP
    ../../../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timers_lwip.c udp.c
    ../../../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
    ../lwip-1.4.1/port/FreeRTOS/netif/: ethernetif.c nuc472_eth.c
    ../lwip-1.4.1/port/FreeRTOS/: sys_arch.c time_stamp.c
  group User
    ../: fs.c httpserver-netconn.c main.c
