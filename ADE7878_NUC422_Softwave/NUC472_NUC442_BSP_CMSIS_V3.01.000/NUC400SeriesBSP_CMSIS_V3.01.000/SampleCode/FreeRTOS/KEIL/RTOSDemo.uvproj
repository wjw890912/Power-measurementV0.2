# Keil uVision project RTOSDemo.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTOSDemo +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000000
  group System
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: QueueSet.c flash.c PollQ.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/SOURCE/: tasks.c timers.c list.c queue.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/RVDS/ARM_CM4F/: port.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c
