# Keil uVision project RcuNet.uvproj, settings and files
target RcuNet (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RcuNet +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\Library\StdDriver\inc;..\;..\..\..\ThirdParty\lwip-1.4.1\src\include;..\..\..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\port\include;..\lwip-1.4.1\port\include\arch;..\lwip-1.4.1\port\include\lwip;..\lwip-1.4.1\port\include\netif;..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000000
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c gpio.c fmc.c wdt.c
  group lwIP
    ../../../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timers_lwip.c udp.c
    ../../../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
    ../lwip-1.4.1/port/netif/: ethernetif.c nuc472_eth.c
