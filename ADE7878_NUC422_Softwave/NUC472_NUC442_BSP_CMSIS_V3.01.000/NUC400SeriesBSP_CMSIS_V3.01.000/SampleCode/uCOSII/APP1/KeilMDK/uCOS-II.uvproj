# Keil uVision project uCOS-II.uvproj, settings and files
target FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: uCOS-II
  AfterMake: fromelf --bin ".\Output\@L.axf" --output ".\Output\@L.bin"
  AfterMake: fromelf --text -c ".\Output\@L.axf" --output ".\Output\@L.txt"
  c flags: Optim=4
  c include: .\;..\;..\..\BSP;..\..\..\..\ThirdParty\uCOS-II\uC-CPU;..\..\..\..\ThirdParty\uCOS-II\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\ThirdParty\uCOS-II\uC-LIB;..\..\..\..\ThirdParty\uCOS-II\uCOS-II\Source;..\..\..\..\ThirdParty\uCOS-II\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  asm define: __TARGET_FPU_VFP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../: app_hooks.c app.c
  group BSP
    ../../BSP/: bsp.c bsp_int.c bsp_os.c
    ../../BSP/KeilMDK/: cstartup.s
  group uC/CPU
    ../../../../ThirdParty/uCOS-II/uC-CPU/: cpu_core.c
    ../../../../ThirdParty/uCOS-II/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../ThirdParty/uCOS-II/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ../../../../ThirdParty/uCOS-II/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-II Source
    ../../../../ThirdParty/uCOS-II/uCOS-II/Source/: ucos_ii.h ucos_ii.c
  group uC/OS-II Port
    ../../../../ThirdParty/uCOS-II/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Dirvers
    ../../../../Library/StdDriver/src/: crypto.c sys.c
