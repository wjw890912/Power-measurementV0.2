# IAR project uCOS-II.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; ..\..\..\..\Library\StdDriver\inc; ; ..; ..\..\..\..\ThirdParty\uCOS-II\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\ThirdParty\uCOS-II\uC-CPU; ..\..\..\..\ThirdParty\uCOS-II\uC-LIB; ..\..\..\..\ThirdParty\uCOS-II\uCOS-II\Source; ..\..\..\..\ThirdParty\uCOS-II\uCOS-II\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\BSP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS-II.bin
  ILINK.IlinkOutputFile: uCOS-II.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group APP
    ../: app.c app_hooks.c
  group BSP
    ../../BSP/: bsp.c bsp_int.c bsp_os.c
    ../../BSP/IAR/: cstartup.c
  group Drivers
    ../../../../Library/StdDriver/src/: crypto.c sys.c
  group uC/CPU
    ../../../../ThirdParty/uCOS-II/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../../../../ThirdParty/uCOS-II/uC-CPU/: cpu_core.c
  group uC/LIB
    ../../../../ThirdParty/uCOS-II/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-II Port
    ../../../../ThirdParty/uCOS-II/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II Source
    ../../../../ThirdParty/uCOS-II/uCOS-II/Source/: ucos_ii.c
