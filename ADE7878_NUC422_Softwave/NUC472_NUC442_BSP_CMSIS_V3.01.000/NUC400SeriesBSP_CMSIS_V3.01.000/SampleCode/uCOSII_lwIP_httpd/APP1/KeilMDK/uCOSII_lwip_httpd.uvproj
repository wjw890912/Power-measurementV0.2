# Keil uVision project uCOSII_lwip_httpd.uvproj, settings and files
target uCOSII_lwip_httpd (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: uCOS-II
  AfterMake: fromelf --bin ".\Output\@L.axf" --output ".\Output\@L.bin"
  AfterMake: fromelf --text -c ".\Output\@L.axf" --output ".\Output\@L.txt"
  c flags: Optim=4
  c include: .\;..\;..\..\BSP;..\..\..\..\ThirdParty\uCOS-II\uC-CPU;..\..\..\..\ThirdParty\uCOS-II\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\ThirdParty\uCOS-II\uC-LIB;..\..\..\..\ThirdParty\uCOS-II\uCOS-II\Source;..\..\..\..\ThirdParty\uCOS-II\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\StdDriver\inc;..\..\lwip-1.4.1\port\uCOS-II\include;..\..\..\..\ThirdParty\lwip-1.4.1\src\include;..\..\lwip-1.4.1\port\uCOS-II\include\arch;..\..\lwip-1.4.1\port\uCOS-II\include\lwip;..\..\lwip-1.4.1\port\uCOS-II\include\netif;..\..\..\..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\..\..\..\Library\CMSIS\Include
  asm define: __TARGET_FPU_VFP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../: app.c app_hooks.c httpserver-netconn.c fs.c
  group BSP
    ../../BSP/: bsp.c bsp_int.c bsp_os.c
    ../../BSP/KeilMDK/: cstartup.s
  group uC/CPU
    ../../../../ThirdParty/uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../ThirdParty/uCOS-II/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../ThirdParty/uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../ThirdParty/uCOS-II/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-II Source
    ../../../../ThirdParty/uCOS-II/uCOS-II/Source/: ucos_ii.c ucos_ii.h
  group uC/OS-II Port
    ../../../../ThirdParty/uCOS-II/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group lwIP
    ../../../../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers_lwip.c udp.c sys_lwip.c
    ../../../../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
  group StdDriver
    ../../../../Library/StdDriver/src/: sys.c
  group lwIP Port
    ../../lwip-1.4.1/port/uCOS-II/: sys_arch.c time_stamp.c
    ../../lwip-1.4.1/port/uCOS-II/netif/: ethernetif.c nuc472_eth.c
