<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uCOSII_lwip_httpd.ewp</path>
  </project>
  <batchBuild/>
</workspace>


