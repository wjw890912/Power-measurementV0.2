# IAR project uCOSII_lwip_httpd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../../../../Library/Device\Nuvoton\NUC472_442\Include; ../../../../Library/CMSIS\Include; ../../../../Library/StdDriver/inc; ../../../../ThirdParty\lwip-1.4.1\src\include\; ../../lwip-1.4.1\port\uCOS-II\include; ../../../../ThirdParty\lwip-1.4.1\src\include\ipv4; ../../../../ThirdParty\uCOS-II\uCOS-II\Source; ..; $PROJ_DIR$; ../../../../ThirdParty\uCOS-II\uC-CPU\ARM-Cortex-M4\IAR; ../../../../ThirdParty\uCOS-II\uC-CPU; ../../../../ThirdParty\uCOS-II\uCOS-II\Ports\ARM-Cortex-M4\Generic\IAR; ../../../../ThirdParty\uCOS-II\uC-LIB; ../../BSP; ../../lwip-1.4.1\port\uCOS-II\include\netif
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOSII_lwip_httpd.bin
  ILINK.IlinkOutputFile: uCOSII_lwip_httpd.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group APP
    ../: app.c app_hooks.c fs.c httpserver-netconn.c
  group BSP
    ../../BSP/: bsp.c bsp_int.c bsp_os.c
    ../../BSP/IAR/: cstartup.c
  group lwIP
    ../../../../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timers_lwip.c udp.c
    ../../../../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
  group lwIP Port
    ../../lwip-1.4.1/port/uCOS-II/netif/: ethernetif.c nuc472_eth.c
    ../../lwip-1.4.1/port/uCOS-II/: sys_arch.c time_stamp.c
  group StdDriver
    ../../../../Library/StdDriver/src/: sys.c
  group uC/CPU
    ../../../../ThirdParty/uCOS-II/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../../../ThirdParty/uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../../../ThirdParty/uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../ThirdParty/uCOS-II/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-II Port
    ../../../../ThirdParty/uCOS-II/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II Source
    ../../../../ThirdParty/uCOS-II/uCOS-II/Source/: ucos_ii.c ucos_ii.h
