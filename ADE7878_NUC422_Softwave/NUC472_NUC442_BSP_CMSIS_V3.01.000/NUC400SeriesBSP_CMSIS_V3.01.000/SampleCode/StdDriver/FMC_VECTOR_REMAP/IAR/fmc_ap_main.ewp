# IAR project fmc_ap_main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fmc_ap_main.bin
  ILINK.IlinkOutputFile: fmc_ap_main.out
  ILINK.IlinkIcfFile: fmc_ap_main.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\fmc_ld_boot.bin,loaderImage1Base,.bin_image,4; --image_input dummy.bin,loaderImage1Limit,.bin_image,4; --image_input Release\Exe\fmc_isp.bin,loaderImage2Base,.bin_image,4; --image_input dummy.bin,loaderImage2Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c
  group User
    ../: ap_main.c
