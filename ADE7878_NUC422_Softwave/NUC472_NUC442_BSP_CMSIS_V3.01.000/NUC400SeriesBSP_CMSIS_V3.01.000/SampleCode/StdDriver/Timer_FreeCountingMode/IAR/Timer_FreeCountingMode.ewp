# IAR project Timer_FreeCountingMode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Timer_FreeCountingMode.bin
  ILINK.IlinkOutputFile: Timer_FreeCountingMode.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
