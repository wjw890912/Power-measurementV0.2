# Keil uVision project USBD_Audio_Speaker.uvproj, settings and files
target USBD_Audio_Speaker (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: USBD_Audio_Speaker
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: main.c descriptors.c usbd_audio.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c usbd.c i2c.c i2s.c timer.c gpio.c uart.c
