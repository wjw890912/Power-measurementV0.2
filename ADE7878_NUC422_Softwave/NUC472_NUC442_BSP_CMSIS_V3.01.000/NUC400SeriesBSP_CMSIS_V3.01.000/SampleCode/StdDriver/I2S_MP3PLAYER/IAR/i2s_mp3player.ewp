# IAR project i2s_mp3player.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __WINS__; OPT_SPEED
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\ThirdParty\FATFS\src; $PROJ_DIR$..\..\..\..\..\ThirdParty\libmad\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: i2s_mp3player.bin
  ILINK.IlinkOutputFile: i2s_mp3player.out
  ILINK.IlinkIcfFile: i2s_mp3player.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c pdma.c retarget.c sd.c sys.c uart.c
  group MP3
    ../../../../ThirdParty/libmad/src/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c MP3Func.c stream.c synth.c timer.c version.c
  group Source
    ../: diskio.c main.c mp3.c MP3HeaderParser.c nau8822.c nuc472_442_isr.c SDGlue.c
