# IAR project USBOTG_Dual_Role_UMAS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\ThirdParty\FATFS\src; $PROJ_DIR$..\..\..\..\..\Library\UsbHostLib\Include; $PROJ_DIR$..\..\..\..\..\Library\UsbHostLib\Include\inc_mass
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbh_umas.bin
  ILINK.IlinkOutputFile: usbotg_dual_role_umas.out
  ILINK.IlinkIcfFile: USBOTG_Dual_Role_UMAS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c usbd.c
    ../../../../ThirdParty/FATFS/src/: ff.c
  group User
    ../: descriptors.c diskio.c main.c MassStorage.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/SOURCE/Core/: usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c usbh_support.c
  group USBH_Mass_Lib
    ../../../../Library/UsbHostLib/SOURCE/MassStor/: Umas_FATFS.c UmasDebug.c UmasDriver.c UmasProtocol.c UmasTransport.c
